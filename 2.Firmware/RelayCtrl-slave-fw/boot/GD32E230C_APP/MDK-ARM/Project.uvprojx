# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_APP (6150000::V6.15::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Z003_Bootload +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\..\GD32E23x_Firmware_Library\CMSIS;..\..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\;..\app;..\drive;..\src;..\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group drive
    ../drive/: usart.c usart.h USART1.c USART1.h fifo.c fifo.h gd32e23x_flash.c gd32e23x_flash.h
  group app
    ../app/: update.c update.h ymodem_slave.c ymodem_slave.h
  group src
    ../src/: gd32e23x_it.c gd32e23x_it.h main.c systick.c systick.h
  group utils
    ../utils/: crc16.c crc16.h
  group CMSIS
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Include/: core_cm23.h gd32e23x.h system_gd32e23x.h gd32e23x_libopt.h
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
software components: CMSIS:CORE 5.0.2
