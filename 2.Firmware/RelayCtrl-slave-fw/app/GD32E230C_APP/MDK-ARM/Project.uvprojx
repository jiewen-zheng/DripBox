# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_START (6150000::V6.15::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe --bin -o  ./mainboard.bin  ./output/app.axf
  c flags: Optim=3 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\..\GD32E23x_Firmware_Library\CMSIS;..\..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\;..\app;..\drive;..\src;..\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8003c00 size 0xbc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group app
    ../app/: update.c update.h command.c command.h other.c other.h motor_ctrl.c motor_ctrl.h
  group drive
    ../drive/: ConstCoor.c ConstCoor.h motor_drive.c motor_drive.h gd32e23x_flash.h gd32e23x_flash.c fifo.c fifo.h usart.c usart.h
  group src
    ../src/: gd32e23x_it.c gd32e23x_it.h main.c systick.c systick.h
  group utils
    ../utils/: crc16.c crc16.h
software components: CMSIS:CORE 5.6.0
